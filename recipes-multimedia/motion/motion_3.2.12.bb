include motion.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"
SRCREV = "${AUTOREV}"
SRC_URI = "git://github.com/Mr-Dave/motion.git"

S = "${WORKDIR}/git"

